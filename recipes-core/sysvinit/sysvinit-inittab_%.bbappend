SYSVINIT_ENABLED_GETTYS = "0"
